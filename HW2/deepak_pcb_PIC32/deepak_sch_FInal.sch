File: HW2/deepak_pcb_PIC32/deepak_sch_FInal.sch (EAGLE design)
At the start: 22 parts, among them J2 USB-MB-H

Commit message: Error checked.
Parts:
- renumbered J2 to USB, U$1 to U1, U$4 to VR
